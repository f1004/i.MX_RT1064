# IAR project Backup of rt1064.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$; C:\Users\Plect\IAR-CMSIS-Packs\NXP\Middleware\10.0.0\freertos\template_application\ARM_CM4F; D:\RT1064\board; D:\RT1064\devices; D:\RT1064\User
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  AARM.AUserIncludes: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  OBJCOPY.OOCOutputFile: rt1064.srec
  ILINK.IlinkOutputFile: rt1064.out
  ILINK.IlinkIcfFile: ${CMSIS_PACK_PATH_NXP#MIMXRT1064_DFP#12.0.0}$iar\MIMXRT1064xxxxx_flexspi_nor.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; $CMSIS_PACK_DEVICE_DEFINES$; _RTE_
  ICCARM.CCIncludePath2: $CMSIS_PACK_DEVICE_INCLUDES$; $CMSIS_PACK_INCLUDES$
  ICCARM.IccLang: 0
  group board
    ../board/: clock_config.c clock_config.h peripherals.c peripherals.h pin_mux.c pin_mux.h
  group device
    ../devices/: led.cc led.h oled.cc oled.h oledfont.h
  group CMSIS-Pack
    RTE/: RTE_Components.h
  group CMSIS-Pack/Device.Startup MIMXRT1064_startup
    RTE/Device/MIMXRT1064DVL6A/: fsl_device_registers.h MIMXRT1064.h MIMXRT1064_features.h MIMXRT1064xxxxx_flexspi_nor.icf MIMXRT1064xxxxx_flexspi_nor_sdram.icf MIMXRT1064xxxxx_ram.icf MIMXRT1064xxxxx_sdram.icf MIMXRT1064xxxxx_sdram_txt.icf startup_MIMXRT1064.s system_MIMXRT1064.c system_MIMXRT1064.h
  group CMSIS-Pack/Device.SDK Project Template RTE_Device
    RTE/Device/MIMXRT1064DVL6A/: RTE_Device.h
  group CMSIS-Pack/CMSIS.DSP Library
    ${CMSIS_PACK_PATH_ARM#CMSIS#5.6.0}$/CMSIS/DSP/Lib/IAR/: iar_cortexM7lf_math.a
  group CMSIS-Pack/NXP MCUXpresso SDK Operating System _Operating System.FreeRTOS Operating System.template_application.freertos_9.0.0
    ${CMSIS_PACK_PATH_NXP#Middleware#10.0.0}$/freertos/Source/portable/MemMang/: heap_1.c heap_2.c heap_3.c heap_4.c heap_5.c
  group CMSIS-Pack/NXP MCUXpresso SDK Operating System _Operating System.FreeRTOS Operating System.freertos_9.0.0
    ${CMSIS_PACK_PATH_NXP#Middleware#10.0.0}$/freertos/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group CMSIS-Pack/Device.SDK Drivers video-i2c
    ${CMSIS_PACK_PATH_NXP#MIMXRT1064_DFP#12.0.0}$/components/video/i2c/: fsl_video_i2c.c
  group CMSIS-Pack/Device.SDK Drivers video-common
    ${CMSIS_PACK_PATH_NXP#MIMXRT1064_DFP#12.0.0}$/components/video/: fsl_video_common.c
  group CMSIS-Pack/Device.SDK Drivers pwm
    ${CMSIS_PACK_PATH_NXP#MIMXRT1064_DFP#12.0.0}$/drivers/: fsl_pwm.c
  group CMSIS-Pack/Device.SDK Drivers pit
    ${CMSIS_PACK_PATH_NXP#MIMXRT1064_DFP#12.0.0}$/drivers/: fsl_pit.c
  group CMSIS-Pack/Device.SDK Drivers lists
    ${CMSIS_PACK_PATH_NXP#MIMXRT1064_DFP#12.0.0}$/components/lists/: generic_list.c
  group CMSIS-Pack/Device.SDK Drivers i2c_edma
    ${CMSIS_PACK_PATH_NXP#MIMXRT1064_DFP#12.0.0}$/drivers/: fsl_lpi2c_edma.c
  group CMSIS-Pack/Device.SDK Drivers i2c
    ${CMSIS_PACK_PATH_NXP#MIMXRT1064_DFP#12.0.0}$/drivers/: fsl_lpi2c.c
  group CMSIS-Pack/Device.SDK Drivers gpio
    ${CMSIS_PACK_PATH_NXP#MIMXRT1064_DFP#12.0.0}$/drivers/: fsl_gpio.c
  group CMSIS-Pack/Device.SDK Drivers flexspi
    ${CMSIS_PACK_PATH_NXP#MIMXRT1064_DFP#12.0.0}$/drivers/: fsl_flexspi.c
  group CMSIS-Pack/Device.SDK Drivers flexio_spi_edma
    ${CMSIS_PACK_PATH_NXP#MIMXRT1064_DFP#12.0.0}$/drivers/: fsl_flexio_spi_edma.c
  group CMSIS-Pack/Device.SDK Drivers flexio_spi
    ${CMSIS_PACK_PATH_NXP#MIMXRT1064_DFP#12.0.0}$/drivers/: fsl_flexio_spi.c
  group CMSIS-Pack/Device.SDK Drivers flexio_i2c_master
    ${CMSIS_PACK_PATH_NXP#MIMXRT1064_DFP#12.0.0}$/drivers/: fsl_flexio_i2c_master.c
  group CMSIS-Pack/Device.SDK Drivers flexio
    ${CMSIS_PACK_PATH_NXP#MIMXRT1064_DFP#12.0.0}$/drivers/: fsl_flexio.c
  group CMSIS-Pack/Device.SDK Drivers edma
    ${CMSIS_PACK_PATH_NXP#MIMXRT1064_DFP#12.0.0}$/drivers/: fsl_edma.c
  group CMSIS-Pack/Device.SDK Drivers dmamux
    ${CMSIS_PACK_PATH_NXP#MIMXRT1064_DFP#12.0.0}$/drivers/: fsl_dmamux.c
  group CMSIS-Pack/Device.SDK Drivers csi
    ${CMSIS_PACK_PATH_NXP#MIMXRT1064_DFP#12.0.0}$/drivers/: fsl_csi.c
  group CMSIS-Pack/Device.SDK Drivers common
    ${CMSIS_PACK_PATH_NXP#MIMXRT1064_DFP#12.0.0}$/drivers/: fsl_common.c
  group CMSIS-Pack/Device.SDK Drivers clock
    ${CMSIS_PACK_PATH_NXP#MIMXRT1064_DFP#12.0.0}$/drivers/: fsl_clock.c
  group CMSIS-Pack/Device.SDK Drivers camera-device-sccb
    ${CMSIS_PACK_PATH_NXP#MIMXRT1064_DFP#12.0.0}$/components/video/camera/device/sccb/: fsl_sccb.c
  group CMSIS-Pack/Device.SDK Drivers camera-device-ov7725
    ${CMSIS_PACK_PATH_NXP#MIMXRT1064_DFP#12.0.0}$/components/video/camera/device/ov7725/: fsl_ov7725.c
  group CMSIS-Pack/Device.SDK Drivers adc_etc
    ${CMSIS_PACK_PATH_NXP#MIMXRT1064_DFP#12.0.0}$/drivers/: fsl_adc_etc.c
  group CMSIS-Pack/Device.SDK Drivers adc_12b1msps_sar
    ${CMSIS_PACK_PATH_NXP#MIMXRT1064_DFP#12.0.0}$/drivers/: fsl_adc.c
  group User
    ../User/: delay.cc delay.h main.cpp
